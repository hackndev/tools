## buildroot/package/openobex/Config.in
```kconfig
config BR2_PACKAGE_OPENOBEX
	bool "openobex"
	default n
	help
	  OpenOBEX protocol
```
